# Keil uVision project RocketControl.uvprojx, settings and files
target mpu6050 (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RocketControl +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_MD
  c include: .\Lib\inc;.\Lib\src;.\CMSIS;.\Startup;.\User;.\Basic\i2c;.\Basic\delay;.\Basic\sys;.\Basic\tim;.\Basic\usart;.\FreeRTOS\include;.\FreeRTOS\portable\RVDS\ARM_CM3;.\Basic\nvic;.\Hardware\mpu6050;.\Hardware\mpu6050\eMPL;.\Basic\dma;.\Basic\nvic;.\Basic\pwm;.\Hardware;.\Basic\internal_flash
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Basic
    ./Basic/delay/: delay.c
    ./Basic/sys/: sys.c
    ./Basic/usart/: usart.c
    ./Basic/dma/: bsp_usart_dma.c
    ./Basic/pwm/: pwm.c
    ./Basic/nvic/: nvic.c
    ./Basic/tim/: tim.c
    ./Basic/internal_flash/: internal_flash.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group Startup
    ./Startup/: startup_stm32f10x_md.s
  group Lib
    ./Lib/src/: misc.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_flash.c stm32f10x_tim.c stm32f10x_dma.c
  group User
    ./User/: main.c stm32f10x_it.c
  group MPU6050/IOIIC
    ./Hardware/mpu6050/: mpuiic.c mpu6050.c
    ./Hardware/mpu6050/eMPL/: inv_mpu.c inv_mpu_dmp_motion_driver.c
  group Hardware
    ./Hardware/: buzzer.c pid.c servo.c
